## config/boards/shields/tottem_left/Kconfig.defconfig
```kconfig
if SHIELD_TOTTEM_LEFT

config ZMK_KEYBOARD_NAME
    default "Tottem Left"

endif
```
